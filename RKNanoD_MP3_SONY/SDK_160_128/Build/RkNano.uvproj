# Keil uVision project RkNano.uvproj, settings and files
target RkNano (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o RkNano.bin  A_CORE\RkNano.axf
  c flags: Optim=3 oTime=1 wLevel=1
  c include: ..\..\Common\Include;..\..\Common\BootLoader;..\..\Common\System\Os;..\..\Common\System\ModuleOverlay;..\..\Common\System\SysService;..\..\Common\System\FileSeek;..\..\Common\Driver;..\..\Common\Driver\NVIC;..\..\Common\Driver\EMCTL;..\..\Common\Driver\ADC;..\..\Common\Driver\DMA;..\..\Common\Driver\PWM;..\..\Common\Driver\I2C;..\..\Common\Driver\IIS;..\..\Common\Driver\CRU;..\..\Common\Driver\SCU;..\..\Common\Driver\PMU;..\..\Common\Driver\GPIO;..\..\Common\Driver\IOMUX;..\..\Common\Driver\SPI;..\..\Common\Driver\TIMER;..\..\Common\Driver\SYSTICK;..\..\Common\Driver\SDMMC;..\..\Common\Driver\LCD;..\..\Common\Driver\KEY;..\..\Common\Driver\AD_KEY;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\rockcodec;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\RadioDriver\FM5767;..\..\Common\FileSys;..\Resource;..\..\Common\Display;..\UI\dialog;..\UI\MainMenu;..\UI\MusicWin;..\UI\RadioWin;..\UI\PicWin;..\UI\RadioWin\RadioSubWin;..\UI\RecordWin;..\UI\TextWin;..\UI\Browser\BroCore;..\UI\Browser\BrowserUI;..\UI\SetMenu;..\UI\USB;..\..\Common\Codec\Audio\AudioControl;..\..\Common\Codec\Audio\Effect;..\..\Common\Codec\Audio\Include;..\..\Common\Codec\Audio\Mp3;..\..\Common\Codec\Audio\Spectrum;..\..\Common\Codec\Audio\RkEQ;..\..\Common\Codec\Audio\RkEQ\Effect;..\..\Common\Codec\Audio\RecordControl;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wav\WAV_LIB;..\..\Common\Codec\Radio;..\..\Common\Codec\Radio\FMControl;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\VideoControl;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Audio\ID3;..\..\Common\Codec\Audio\ID3\MusicAlbumJpgDec;..\UI\block;..\..\Common\SortFileInfo;..\UI\medialib;..\Scatter;..\..\Common\Driver\UART;..\..\Common\Driver\IMDCT36_SYNTH;..\..\Common\Driver\Nand;..\..\Common\Codec\Audio\ShuffleAll;..\..\Common\System\Mtp;..\..\Common\System\Mdb;..\..\Common\System\Mdb\id3;..\..\Common\Driver\MemDev\Nand;..\..\Common\Driver\RTC;..\..\Common\Driver\USB;..\..\Common\Driver\USB\device;..\..\Common\Driver\MemDev;..\UI\CharegeWin;..\..\Common\Driver\MemDev\SD_MMC;..\..\Common\Codec\UsbControl;..\..\Common\Codec\Audio\RecordControl\NS;..\..\Common\FwUpdate;..\UI\dialog;..\UI\SetMenu;..\..\SDK_160_128;..\..\Common\Driver\vop;..\..\Common\Driver\vop;..\..\Common\Driver\mailbox;..\UI\PicWin;..\..\Common\Codec\Image;..\..\Common\Codec\Image\Bmp;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Image\ImageInclude;..\..\Common\Codec\Image\Jpg;..\..\Common\Codec\Video;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Driver\GRF;..\..\Common\Driver\WatchDog;..\..\Common\Driver\PVTM;..\..\Common\Driver\DAC\ALC5633;..\..\Common\Driver\PMC;..\..\Common\Plug\uartdevice;..\UI\MusicWin;..\..\Common\Plug\bsp;..\..\Common\Plug\shell;..\..\Common\Plug\uartdevice;..\..\Common\BBSystem;..\..\Common\Codec\Audio\AAC;..\..\Common\Codec\Audio\APE;..\..\Common\Codec\Audio\flac;..\..\Common\Codec\Audio\Ogg;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wma;..\..\Common\Codec\Audio\HIFI\ape;..\..\Common\Codec\Audio\HIFI\alac;..\..\Common\Codec\Audio\HIFI\flac;..\UI\TextWin;..\..\Common\Codec\Image\Thumbnail;..\..\Common\Driver\BB;..\UI\M3U;..\UI\BlueToothWin;..\UI\BlueToothWin\a2dpSoucreWin;..\..\Common\Codec\BlueTooth;..\..\Common\Codec\BlueTooth\lwbt;..\..\Common\Codec\BlueTooth\lwbt\a2dp_source;..\..\Common\Codec\BlueTooth\lwbt\chipset_rtk8761a;..\..\Common\Codec\Audio\Aec;..\..\Common\Codec\Audio\sbc;..\..\Common\Codec\Audio\SSRC;..\..\Common\Codec\Audio\SSRC\resampler
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
  link misc: --entry Main1 --keep ModuleInfo --keep exceptions_table --keep MainStack1 --keep V0_8K --keep V0_11K --keep V0_12K --keep V0_16K --keep V0_22K --keep V0_24K --keep V0_32K --keep V0_44K --keep V0_48K --keep V03_48K --keep V03_44K --keep V03_32K --keep V03_22K --keep V03_24K --keep V03_16K --keep V03_12K --keep V03_11K --keep V03_8K --keep V04_8K --keep V04_11K --keep V04_12K --keep V04_16K --keep V04_22K --keep V04_24K --keep V04_32K --keep V04_44K --keep V04_48K --keep V07_48K --keep V07_44K --keep V07_32K --keep V07_24K  --keep V07_22K --keep V07_16K --keep V07_12K --keep V07_11K --keep V07_8K --keep V09_8K --keep V09_11K --keep V09_12K --keep V09_16K --keep V09_22K --keep V09_24K --keep V09_32K --keep V09_44K --keep V09_48K --keep V10_48K --keep V10_44K --keep V10_32K --keep V10_24K --keep V10_22K --keep V10_16K --keep V10_12K --keep V10_11K --keep V10_8K --keep V11_8K --keep V11_11K --keep V11_12K --keep V11_16K --keep V11_22K --keep V11_24K --keep V11_32K --keep V11_44K --keep V11_48K --keep V08_48K --keep V08_44K --keep V08_32K  --keep V08_24K --keep V08_22K --keep V08_16K  --keep V08_12K --keep V08_11K --keep V08_8K --keep C3 --keep C5 --keep C9 --keep C21 --keep C22 --keep C49 --keep C50 --keep Eq_Table --keep mp3_code_bin --keep mp3_data_bin --keep mp3_enc_code_bin --keep mp3_enc_data_bin --keep wav_code_bin --keep wav_data_bin --keep aac_code_bin --keep aac_data_bin --keep wma_code_bin --keep wma_data_bin --keep flac_code_bin --keep flac_data_bin
  group Boot
    ../Scatter/: ScatterLoader.c
    ../../Common/BootLoader/: Start.s Cortex-m3.S
  group Driver
    ../../Common/Driver/PMU/: PMU.C
    ../../Common/Driver/ADC/: Adc.c
    ../../Common/Driver/DMA/: Dma.c
    ../../Common/Driver/I2C/: i2c.c
    ../../Common/Driver/IIS/: I2s.c
    ../../Common/Driver/GPIO/: gpio.c
    ../../Common/Driver/SPI/: Spi.c
    ../../Common/Driver/SYSTICK/: systick.c
    ../../Common/Driver/TIMER/: timer.c
    ../../Common/Driver/AD_KEY/: AD_Key.c
    ../../Common/Driver/UART/: uart.c
    ../../Common/Driver/DAC/rockcodec/: rockcodec.c
    ../../Common/Codec/UsbControl/: USBControl.c
    ../../Common/Driver/RadioDriver/QN8035/: hw_qn8035.c
    ../../Common/Driver/RadioDriver/FM5807/: hw_fm5807.c
    ../../Common/Driver/LCD/: Lcd_S6B0724_96x64.c ST7735Driver.c ST7735S_Driver_1.0.c
    ../../Common/Driver/DAC/wm8987/: hw_wm8987.c
    ../../Common/Driver/vop/: vop.c yuv2rgb.c
    ../../Common/Driver/mailbox/: mailbox.c
    ../../Common/Driver/CRU/: cru.c
    ../../Common/Driver/GRF/: grf.c
    ../../Common/Driver/PWM/: pwm.c
    ../../Common/Driver/WatchDog/: WatchDog.c
    ../../Common/Driver/DAC/ALC5633/: Hw_alc5633.c
    ../../Common/Driver/pmc/: pmc.c
    ../../Common/Driver/PVTM/: pvtm.c
    ../../Common/Driver/hifi/: hifi.c hifi_alac.c hifi_ape.c hifi_fft.c hifi_flac.c hifi_mac.c
    ../../Common/Driver/BB/: BBSystem.c
  group System
    ../../Common/System/Debug/: Debug.c
    ../: main.c
    ../../Common/System/SysService/: Hook.c Delay.c Backlight.c battery.c Service.c UsbAdapterProbe.c voicedata0000.c voicedata0001.c voicedata0002.c voicedata0003.c voicedata0004.c voicedata0005.c voicedata0006.c voicedata0007.c voicedata0008.c PowerManager.c
    ../../Common/Display/: LcdCharLib.c LcdChar.c LcdImage.c LcdInterface.c 8859_x_12_add9.c 8859_x_12_Width_add9.c 8859_x_Table_add9.c COMP_NewJ_12_CJK.c COMP_NewJ_12_JKC.c COMP_NewJ_tbl.c FontLib.c getThaiChar.c THAI12.c
    ../../Common/System/Os/: interrupt.c SysTickHandler.c
    ../../Common/System/FileSeek/: SysFindFile.c
    ../../Common/Plug/shell/: ShellTask.c
  group OsLib
    ../../Common/System/Os/: Msg.c Win.c Thread.c Task.c OsHook.c
    ../../Common/System/ModuleOverlay/: ModuleOverlay.c SysReservedOperation.c
    ../../Common/FwUpdate/: FwUpdate.c
  group FileSys
    ../../Common/FileSys/: Decode.c nFAT.c fat.c FDT.c dir.c file.c FileSeek.c
  group App
    ../UI/dialog/: DialogBox.c MessageBox.c LowPower.c Hold.c PowerOn_Off.c
    ../UI/MainMenu/: MainMenu.c MainMenuInterface.c
    ../UI/MusicWin/: MusicWin.c MusicWinInterface.c MusicLrc.c
    ../UI/RadioWin/: RadioWin.c RadioWinInterface.c
    ../UI/RadioWin/RadioSubWin/: RadioSubFreqWin.c RadioSubFuncWin.c RadioSubWinInterface.c
    ../UI/RecordWin/: RecordWin.c RecordWinInterface.c
    ../UI/Browser/BrowserUI/: BrowserUI.c
    ../UI/Browser/BroCore/: BroCore.c
    ../UI/SetMenu/: SetMenu.c SystemSet.c SetCommon.c SetMenuInterface.c SetMusic.c SetRadio.c SetRecord.c SetText.c SetBright.c BluetoothScanWin.c SetBluetooth.c BluetoothDevInfoWin.c BluetoothPinCodeWin.c
    ../UI/USB/: FunUSB.c FunUSBInterface.c
    ../UI/CharegeWin/: ChargeWin.c
    ../UI/PicWin/: PicInterface.c PicWin.c PicBroWin.c
    ../UI/TextWin/: TextBookmark.c TextInterface.c TextWin.c
    ../UI/M3U/: M3uBroWin.c M3uWin.c M3uWinSub.c
  group AudioControl
    ../../Common/Codec/Audio/AudioControl/: AudioControl.c HoldonPlay.c
    ../../Common/Codec/Audio/Common/: audio_file_access.c audio_track_control.c pCODECS.c
  group RecordControl
    ../../Common/Codec/Audio/RecordControl/: RecordControl.c
  group RadioControl
    ../../Common/Codec/Radio/FMControl/: FmControl.c
  group Mp3Lib
    ../../Common/Codec/Audio/Mp3/: pMP3.c pMP32.c RkNanoD_MP3_20151119.lib
    ../../Common/Codec/Audio/Mp3/libMad/: mp3_accelerator_hal.c mp3_bit.c mp3_decinternal.c mp3_decoder.c mp3_fixed.c mp3_frame.c mp3_layer3.c mp3_layer12.c mp3_preparse.c mp3_rom_tbl.c mp3_stream.c mp3_synth_internal.c mp3_synth_stereo.c
  group MP3EncLib
    ../../Common/Codec/Audio/MP3_ENC/: pMp3Enc.c RkNanoD_MP3Enc_20151119.lib
    ../../Common/Codec/Audio/MP3_ENC/MP3_enc_lib/: pMp3Enc2.c mp3_enc_bitstream.c mp3_enc_coder.c mp3_enc_huffman.c mp3_enc_layer3.c mp3_enc_loop.c mp3_enc_utils.c
  group WavLib
    ../../Common/Codec/Audio/Wav/: pWAV.c pWAV2.c pWAVEnc.c RkNanoD_WAV_20151119.lib
    ../../Common/Codec/Audio/Wav/WAV_LIB/: pWAV_lib.c wav_ImaDecoder.c wav_msadpcm_dec.c wav_msadpcm_enc.c
  group Wmalib
    ../../Common/Codec/Audio/Wma/: pWMA2.c pWMA.c RkNanoD_WMA_20151119.lib
    ../../Common/Codec/Audio/Wma/wmalib/: wma_audio_table_room.c wma_configcommon.c wma_decrypt.c wma_dectablesstd.c wma_dectablesstdpro.c wma_drmpd.c wma_drmpd_table.c wma_entropydec.c wma_entropydecstd.c wma_fft_wma.C wma_HUFFDEC.C wma_lowrate_commonstd.c wma_LPCSTD.C wma_MSAUDIO.C wma_msaudiodec.c wma_msaudiostd.c wma_msaudiostdpro.c wma_msaudiotemplate.c wma_strmdec_wma.c wmaLibTop.c WMAUDIO.C wmaudio_audec.c wmaudio_parse.c
  group AacLib
    ../../Common/Codec/Audio/AAC/: pAAC.c pAAC2.c RkNanoD_AAC_20151119.lib
    ../../Common/Codec/Audio/AAC/lib/: aac_aacdec.c aac_aactabs.c aac_assembly.c aac_bitstream.c aac_buffers.c aac_dct4.c aac_decelmnt.c aac_dequant.c aac_fft.c aac_filefmt.c aac_huffman.c aac_hufftabs.c aac_imdct.c aac_MovFile.c aac_movparserinterface.c aac_noiseless.c aac_pns.c aac_stproc.c aac_tns.c aac_trigtabs.c
    ../../Common/Codec/Audio/AAC/lib/aac_gen_table/: aac_table_rom.c
  group FlacLib
    ../../Common/Codec/Audio/flac/: pFLAC.c pFLAC2.c
    ../../Common/Codec/Audio/flac/Flac_lib/: flac_analyze.c flac_bitbuffer.c flac_bitmath.c flac_buffer.c flac_crc.c flac_dec_internal.c flac_decode.c flac_file_decoder.c flac_file_io.c flac_fixed.c flac_format.c flac_lpc.c flac_seekable_stream_decoder.c flac_stream_decoder.c flac_tab.c flac_utils.c flac_get_bits.c
  group EqLib
    ../../Common/Codec/Audio/RkEQ/Effect/: Effect.c
    ../../Common/Codec/Audio/Library/: RkNano_Spectrum_V09_0420.lib
    ../../Common/Codec/Audio/ShuffleAll/myRandom/: myRandom.c
    ../../Common/Codec/Audio/RkEQ/: Fade.c filter_2_int_l.s filter_2_int_r.s rk_eq.c rk_eq_asm_opt.s
  group NS
    ../../Common/Codec/Audio/RecordControl/NS/: NS_fftwrap.c NS_filterbank.c NS_interface.c NS_kiss_fft.c NS_kiss_fftr.c NS_preprocess.c
    ../../Common/Codec/Audio/RecordControl/: RkNanoD_NS_20151119.lib
  group ID3
    ../../Common/Codec/Audio/ID3/: ID3.c wma_parse.c AsicToUnicode.c AsicToUnicodeTable.c
  group media
    ../UI/medialib/: MediaBroWin.c medialibwin.c
    ../../Common/SortFileInfo/: FavoOperate.c FavoReset.c FileInfoSave.c SortInfoGet.c FileInfoSort.c
    ../UI/Medialib/: MDBBuildWin.c
  group USB
    ../../Common/Driver/USB/device/: storage.c USBDevice.c USBIsr.c USBSerial.c
    ../../Common/Driver/USB/: USBComm.c
  group MemDev
    ../../Common/Driver/MemDev/: MemDev.c
    ../../Common/Driver/MemDev/SD_MMC/: SDM.c eMMC.c MMC.c SD.c SDCtrl.c SDAdapt.c
    ../../Common/Driver/MemDev/SPIFlash/: SPIFlash.c SFC.c SFNand.c SFNor.c
  group ImageControl
    ../../Common/Codec/Image/ImageCommon/: image_common.c image_file_access.c pImageCODECS.c
    ../../Common/Codec/Image/Imagecontrol/: ImageControl.c
  group Thumbnail
    ../../Common/Codec/Image/Thumbnail/: thumbnail_parse.c Exif_Read.c Exif_Read_Main.c Thumbnail_Read_Main.c Thumbnail_Read_Task.c
  group JpgLib
    ../../Common/Codec/Image/Jpg/: pJPG.c jpgdec_init.c jpgdec_parser.c RkNanoD_JPG_DEC_V150906.lib
  group BmpLib
    ../../Common/Codec/Image/Bmp/: pBMPDEC.c RkNano_BMP_DEC_V20150511.lib
  group Plug
    ../../Common/Plug/bsp/: BSP.c
    ../../Common/Plug/uartdevice/: UartDevice.c
  group BBSystem
    ../../Common/BBSystem/: audio_file_access2.c BSP2.c cru2.c Debug2.c Delay2.c dma2.c interrupt2.c Main2.c pCODECS2.c systick2.c SysTickHandler2.c Cortex-m32.S Start2.s
  group BB_CORE_BIN
    ../../Common/System/SysService/: bb_core.c
  group BTControl
    ../../Common/Codec/BlueTooth/lwbt/a2dp_source/: bt_ip_dt_source.c
    ../../Common/Codec/BlueTooth/lwbt/chipset_rtk8761a/: btRtk8761aControl.c btRtk8761a_init_script.c
    ../../Common/Codec/BlueTooth/lwbt/: uartif_h5.c btHwControl.c
    ../../Common/Codec/BlueTooth/: BlueToothA2dpSourceControl.c BlueToothSysParam.c
  group LWBT
    ../../Common/Codec/BlueTooth/lwbt/: hci.c inet.c l2cap.c lwbt_memp.c pbuf.c sdp.c uartif.c
    ../../Common/Codec/BlueTooth/lwbt/a2dp_source/: avctp_source.c avdtp_source.c avrcp_source.c
  group SBCEncode
    ../../Common/Codec/Audio/sbc/sbc_encode/: sbc_enc_interface.c sbc_encode.c
  group SSRC
    ../../Common/Codec/Audio/SSRC/: resample_interface.c
    ../../Common/Codec/Audio/SSRC/resampler/: src.c
  group SBCLib
    ../../Common/Codec/Audio/sbc/: sbc.c sbc_interface.c sbcFunc.c
  group AECLib
    ../../Common/Codec/Audio/Aec/: aec_fftwrap.c aec_filterbank.c aec_interface.c aec_kiss_fft.c aec_kiss_fftr.c aec_mdf.c aec_preprocess.c
target MP3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o MP3\RkNano.bin  MP3\RkNano.axf
  AfterMake: mp3.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: MP3_DEC_INCLUDE2, B_CORE_DECODE
  c include: ..\..\Common\Include;..\..\Common\BootLoader;..\..\Common\System\Os;..\..\Common\System\ModuleOverlay;..\..\Common\System\SysService;..\..\Common\System\FileSeek;..\..\Common\Driver;..\..\Common\Driver\NVIC;..\..\Common\Driver\EMCTL;..\..\Common\Driver\ADC;..\..\Common\Driver\DMA;..\..\Common\Driver\PWM;..\..\Common\Driver\I2C;..\..\Common\Driver\IIS;..\..\Common\Driver\CRU;..\..\Common\Driver\SCU;..\..\Common\Driver\PMU;..\..\Common\Driver\GPIO;..\..\Common\Driver\IOMUX;..\..\Common\Driver\SPI;..\..\Common\Driver\TIMER;..\..\Common\Driver\SYSTICK;..\..\Common\Driver\SDMMC;..\..\Common\Driver\LCD;..\..\Common\Driver\KEY;..\..\Common\Driver\AD_KEY;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\rockcodec;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\RadioDriver\FM5767;..\..\Common\FileSys;..\Resource;..\..\Common\Display;..\UI\dialog;..\UI\MainMenu;..\UI\MusicWin;..\UI\RadioWin;..\UI\PicWin;..\UI\RadioWin\RadioSubWin;..\UI\RecordWin;..\UI\TextWin;..\UI\Browser\BroCore;..\UI\Browser\BrowserUI;..\UI\SetMenu;..\UI\USB;..\..\Common\Codec\Audio\AudioControl;..\..\Common\Codec\Audio\Effect;..\..\Common\Codec\Audio\Include;..\..\Common\Codec\Audio\Mp3;..\..\Common\Codec\Audio\Spectrum;..\..\Common\Codec\Audio\RkEQ;..\..\Common\Codec\Audio\RkEQ\Effect;..\..\Common\Codec\Audio\RecordControl;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wav\WAV_LIB;..\..\Common\Codec\Radio;..\..\Common\Codec\Radio\FMControl;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\VideoControl;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Audio\ID3;..\..\Common\Codec\Audio\ID3\MusicAlbumJpgDec;..\UI\block;..\..\Common\SortFileInfo;..\UI\medialib;..\Scatter;..\..\Common\Driver\UART;..\..\Common\Driver\IMDCT36_SYNTH;..\..\Common\Driver\Nand;..\..\Common\Codec\Audio\ShuffleAll;..\..\Common\System\Mtp;..\..\Common\System\Mdb;..\..\Common\System\Mdb\id3;..\..\Common\Driver\MemDev\Nand;..\..\Common\Driver\RTC;..\..\Common\Driver\USB;..\..\Common\Driver\USB\device;..\..\Common\Driver\MemDev;..\UI\CharegeWin;..\..\Common\Driver\MemDev\SD_MMC;..\..\Common\Codec\UsbControl;..\..\Common\Codec\Audio\RecordControl\NS;..\..\Common\FwUpdate;..\UI\dialog;..\UI\SetMenu;..\..\SDK_160_128;..\..\Common\Driver\vop;..\..\Common\Driver\vop;..\..\Common\Driver\mailbox;..\UI\PicWin;..\..\Common\Codec\Image;..\..\Common\Codec\Image\Bmp;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Image\ImageInclude;..\..\Common\Codec\Image\Jpg;..\..\Common\Codec\Video;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Driver\GRF;..\..\Common\Driver\WatchDog;..\..\Common\Driver\PVTM;..\..\Common\Driver\DAC\ALC5633;..\..\Common\Driver\PMC;..\..\Common\Plug\uartdevice;..\UI\MusicWin;..\..\Common\Plug\bsp;..\..\Common\Plug\shell;..\..\Common\Plug\uartdevice;..\..\Common\BBSystem;..\..\Common\Codec\Audio\AAC;..\..\Common\Codec\Audio\APE;..\..\Common\Codec\Audio\flac;..\..\Common\Codec\Audio\Ogg;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wma;..\..\Common\Codec\Audio\HIFI\ape;..\..\Common\Codec\Audio\HIFI\alac;..\..\Common\Codec\Audio\HIFI\flac;..\UI\TextWin;..\..\Common\Codec\Image\Thumbnail;..\..\Common\Driver\BB;..\UI\M3U
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: --keep V0_8K --keep V0_11K --keep V0_12K --keep V0_16K --keep V0_22K --keep V0_24K --keep V0_32K --keep V0_44K --keep V0_48K --keep V03_48K --keep V03_44K --keep V03_32K --keep V03_22K --keep V03_24K --keep V03_16K --keep V03_12K --keep V03_11K --keep V03_8K --keep V04_8K --keep V04_11K --keep V04_12K --keep V04_16K --keep V04_22K --keep V04_24K --keep V04_32K --keep V04_44K --keep V04_48K --keep V07_48K --keep V07_44K --keep V07_32K --keep V07_24K  --keep V07_22K --keep V07_16K --keep V07_12K --keep V07_11K --keep V07_8K --keep V09_8K --keep V09_11K --keep V09_12K --keep V09_16K --keep V09_22K --keep V09_24K --keep V09_32K --keep V09_44K --keep V09_48K --keep V10_48K --keep V10_44K --keep V10_32K --keep V10_24K --keep V10_22K --keep V10_16K --keep V10_12K --keep V10_11K --keep V10_8K --keep V11_8K --keep V11_11K --keep V11_12K --keep V11_16K --keep V11_22K --keep V11_24K --keep V11_32K --keep V11_44K --keep V11_48K --keep V08_48K --keep V08_44K --keep V08_32K  --keep V08_24K --keep V08_22K --keep V08_16K  --keep V08_12K --keep V08_11K --keep V08_8K --keep ModuleInfo --keep Eq_Table --keep bass_60_tbl --keep bass_120_tbl --keep llushr.o --keep llsshr.o --keep siabs.o --keep memmovea.o --keep memseta.o --keep strcat.o --keep strncpy.o --keep strxfrm.o --keep strchr.o --keep strlen.o --keep strcmp.o --keep memchr.o --keep memcmp.o --keep strncat.o --keep strcoll.o --keep strcpy.o --keep strncmp.o --keep strrchr.o --keep strspn.o --keep strcspn.o --keep strpbrk.o --keep dadd.o --keep dmul.o --keep ddiv.o --keep dflt.o --keep dfltu.o --keep dfltll.o --keep dfltull.o --keep dfix.o --keep dfixu.o --keep dfixll.o --keep dfixull.o --keep f2d.o --keep cdcmple.o --keep cdrcmple.o --keep fadd.o --keep fmul.o --keep fdiv.o --keep fflt.o --keep ffltu.o --keep ffltll.o --keep ffltull.o --keep ffix.o --keep ffixu.o --keep ffixll.o --keep ffixull.o --keep d2f.o --keep cfcmple.o --keep cfrcmple.o --keep iusefp.o --keep depilogue.o --keep fepilogue.o --keep C3 --keep C5 --keep C50 --keep C21 --keep C22 --keep C49 --keep C
target AAC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o AAC\RkNano.bin  AAC\RkNano.axf
  AfterMake: aac.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: AAC_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target WMA (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o WMA\RkNano.bin  WMA\RkNano.axf
  AfterMake: wma.bat
  c flags: Optim=3 oTime=1 wLevel=1
  c define: WMA_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target WAV (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o WAV\RkNano.bin  WAV\RkNano.axf
  AfterMake: wav.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: WAV_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target FLAC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o FLAC\RkNano.bin  FLAC\RkNano.axf
  AfterMake: flac.bat
  c flags: Optim=3 wLevel=1
  c define: FLAC_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target MP3Enc (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o MP3ENC\RkNano.bin  MP3ENC\RkNano.axf
  AfterMake: mp3enc.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: MP3_ENC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target MP3_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNanoD_MP3 (library)
  c flags: Optim=4 oTime=1 wLevel=1
  c define: MP3_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target AAC_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNanoD_AAC (library)
  c flags: Optim=4 oTime=1 wLevel=1
  c define: AAC_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target WMA_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNanoD_WMA (library)
  c flags: Optim=3 oTime=1 wLevel=1
  c define: WMA_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target WAV_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNanoD_WAV (library)
  c flags: Optim=4 oTime=1 wLevel=1
  c define: WAV_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target FLAC_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RKNanoD_FLAC (library)
  c flags: Optim=3 wLevel=1
  c define: FLAC_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target MP3Enc_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNanoD_MP3Enc (library)
  c flags: Optim=4 oTime=1 wLevel=1
  c define: MP3_ENC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target NS_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNanoD_NS (library)
  c flags: Optim=4 oTime=1 wLevel=1
  c define: MP3_ENC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
  link misc: as above
target LWBT_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RKNanoD_LwBT (library)
  AfterMake: fromELF --bin -o RkNano.bin  A_CORE\RkNano.axf
  c flags: Optim=3 oTime=1 wLevel=1
  c include: ..\..\Common\Include;..\..\Common\BootLoader;..\..\Common\System\Os;..\..\Common\System\ModuleOverlay;..\..\Common\System\SysService;..\..\Common\System\FileSeek;..\..\Common\Driver;..\..\Common\Driver\NVIC;..\..\Common\Driver\EMCTL;..\..\Common\Driver\ADC;..\..\Common\Driver\DMA;..\..\Common\Driver\PWM;..\..\Common\Driver\I2C;..\..\Common\Driver\IIS;..\..\Common\Driver\CRU;..\..\Common\Driver\SCU;..\..\Common\Driver\PMU;..\..\Common\Driver\GPIO;..\..\Common\Driver\IOMUX;..\..\Common\Driver\SPI;..\..\Common\Driver\TIMER;..\..\Common\Driver\SYSTICK;..\..\Common\Driver\SDMMC;..\..\Common\Driver\LCD;..\..\Common\Driver\KEY;..\..\Common\Driver\AD_KEY;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\rockcodec;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\RadioDriver\FM5767;..\..\Common\FileSys;..\Resource;..\..\Common\Display;..\UI\dialog;..\UI\MainMenu;..\UI\MusicWin;..\UI\RadioWin;..\UI\PicWin;..\UI\RadioWin\RadioSubWin;..\UI\RecordWin;..\UI\TextWin;..\UI\Browser\BroCore;..\UI\Browser\BrowserUI;..\UI\SetMenu;..\UI\USB;..\..\Common\Codec\Audio\AudioControl;..\..\Common\Codec\Audio\Effect;..\..\Common\Codec\Audio\Include;..\..\Common\Codec\Audio\Mp3;..\..\Common\Codec\Audio\Spectrum;..\..\Common\Codec\Audio\RkEQ;..\..\Common\Codec\Audio\RkEQ\Effect;..\..\Common\Codec\Audio\RecordControl;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wav\WAV_LIB;..\..\Common\Codec\Radio;..\..\Common\Codec\Radio\FMControl;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\VideoControl;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Audio\ID3;..\..\Common\Codec\Audio\ID3\MusicAlbumJpgDec;..\UI\block;..\..\Common\SortFileInfo;..\UI\medialib;..\Scatter;..\..\Common\Driver\UART;..\..\Common\Driver\IMDCT36_SYNTH;..\..\Common\Driver\Nand;..\..\Common\Codec\Audio\ShuffleAll;..\..\Common\System\Mtp;..\..\Common\System\Mdb;..\..\Common\System\Mdb\id3;..\..\Common\Driver\MemDev\Nand;..\..\Common\Driver\RTC;..\..\Common\Driver\USB;..\..\Common\Driver\USB\device;..\..\Common\Driver\MemDev;..\UI\CharegeWin;..\..\Common\Driver\MemDev\SD_MMC;..\..\Common\Codec\UsbControl;..\..\Common\Codec\Audio\RecordControl\NS;..\..\Common\FwUpdate;..\UI\dialog;..\UI\SetMenu;..\..\SDK_160_128;..\..\Common\Driver\vop;..\..\Common\Driver\vop;..\..\Common\Driver\mailbox;..\UI\PicWin;..\..\Common\Codec\Image;..\..\Common\Codec\Image\Bmp;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Image\ImageInclude;..\..\Common\Codec\Image\Jpg;..\..\Common\Codec\Video;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Driver\GRF;..\..\Common\Driver\WatchDog;..\..\Common\Driver\PVTM;..\..\Common\Driver\DAC\ALC5633;..\..\Common\Driver\PMC;..\..\Common\Plug\uartdevice;..\UI\MusicWin;..\..\Common\Plug\bsp;..\..\Common\Plug\shell;..\..\Common\Plug\uartdevice;..\..\Common\BBSystem;..\..\Common\Codec\Audio\AAC;..\..\Common\Codec\Audio\APE;..\..\Common\Codec\Audio\flac;..\..\Common\Codec\Audio\Ogg;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wma;..\..\Common\Codec\Audio\HIFI\ape;..\..\Common\Codec\Audio\HIFI\alac;..\..\Common\Codec\Audio\HIFI\flac;..\UI\TextWin;..\..\Common\Codec\Image\Thumbnail;..\..\Common\Driver\BB;..\UI\M3U;..\UI\BlueToothWin;..\UI\BlueToothWin\a2dpSoucreWin;..\..\Common\Codec\BlueTooth;..\..\Common\Codec\BlueTooth\lwbt;..\..\Common\Codec\BlueTooth\lwbt\a2dp_source;..\..\Common\Codec\BlueTooth\lwbt\BLE;..\..\Common\Codec\BlueTooth\lwbt\chipset_cc2564;..\..\Common\Codec\BlueTooth\lwbt\chipset_rtk8761a;..\..\Common\Codec\Audio\Aec;..\..\Common\Codec\Audio\sbc;..\..\Common\Codec\Audio\SSRC;..\..\Common\Codec\Audio\SSRC\resampler
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
  link misc: as above
target SSRC_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RKNanoD_SSRC (library)
  AfterMake: fromELF --bin -o RkNano.bin  A_CORE\RkNano.axf
  c flags: Optim=3 oTime=1 wLevel=1
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
  link misc: as above
target SBCENCODE_LIB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RKNanoD_SBCEnc (library)
  AfterMake: fromELF --bin -o RkNano.bin  A_CORE\RkNano.axf
  c flags: Optim=3 oTime=1 wLevel=1
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
  link misc: as above
