# Keil uVision project RkNano.uvproj, settings and files
target RkNano (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o RkNano.bin  A_CORE\RkNano.axf
  c flags: Optim=3 oTime=1 wLevel=1
  c include: ..\..\Common\Include;..\..\Common\BootLoader;..\..\Common\System\Os;..\..\Common\System\ModuleOverlay;..\..\Common\System\SysService;..\..\Common\System\FileSeek;..\..\Common\Driver;..\..\Common\Driver\NVIC;..\..\Common\Driver\EMCTL;..\..\Common\Driver\ADC;..\..\Common\Driver\DMA;..\..\Common\Driver\PWM;..\..\Common\Driver\I2C;..\..\Common\Driver\IIS;..\..\Common\Driver\CRU;..\..\Common\Driver\SCU;..\..\Common\Driver\PMU;..\..\Common\Driver\GPIO;..\..\Common\Driver\IOMUX;..\..\Common\Driver\SPI;..\..\Common\Driver\TIMER;..\..\Common\Driver\SYSTICK;..\..\Common\Driver\SDMMC;..\..\Common\Driver\LCD;..\..\Common\Driver\KEY;..\..\Common\Driver\AD_KEY;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\rockcodec;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\RadioDriver\FM5767;..\..\Common\FileSys;..\Resource;..\..\Common\Display;..\UI\dialog;..\UI\MainMenu;..\UI\MusicWin;..\UI\RadioWin;..\UI\PicWin;..\UI\RadioWin\RadioSubWin;..\UI\RecordWin;..\UI\TextWin;..\UI\Browser\BroCore;..\UI\Browser\BrowserUI;..\UI\SetMenu;..\UI\USB;..\..\Common\Codec\Audio\AudioControl;..\..\Common\Codec\Audio\Effect;..\..\Common\Codec\Audio\Include;..\..\Common\Codec\Audio\Mp3;..\..\Common\Codec\Audio\Spectrum;..\..\Common\Codec\Audio\RkEQ;..\..\Common\Codec\Audio\RkEQ\Effect;..\..\Common\Codec\Audio\RecordControl;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wav\WAV_LIB;..\..\Common\Codec\Radio;..\..\Common\Codec\Radio\FMControl;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\VideoControl;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Audio\ID3;..\..\Common\Codec\Audio\ID3\MusicAlbumJpgDec;..\UI\block;..\..\Common\SortFileInfo;..\UI\medialib;..\Scatter;..\..\Common\Driver\UART;..\..\Common\Driver\IMDCT36_SYNTH;..\..\Common\Driver\Nand;..\..\Common\Codec\Audio\ShuffleAll;..\..\Common\System\Mtp;..\..\Common\System\Mdb;..\..\Common\System\Mdb\id3;..\..\Common\Driver\MemDev\Nand;..\..\Common\Driver\RTC;..\..\Common\Driver\USB;..\..\Common\Driver\USB\device;..\..\Common\Driver\MemDev;..\UI\CharegeWin;..\..\Common\Driver\MemDev\SD_MMC;..\..\Common\Codec\UsbControl;..\..\Common\Codec\Audio\RecordControl\NS;..\..\Common\FwUpdate;..\UI\dialog;..\UI\SetMenu;..\..\SDK_160_128;..\..\Common\Driver\vop;..\..\Common\Driver\vop;..\..\Common\Driver\mailbox;..\UI\PicWin;..\..\Common\Codec\Image;..\..\Common\Codec\Image\Bmp;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Image\ImageInclude;..\..\Common\Codec\Image\Jpg;..\..\Common\Codec\Video;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Driver\GRF;..\..\Common\Driver\WatchDog;..\..\Common\Driver\PVTM;..\..\Common\Driver\DAC\ALC5633;..\..\Common\Driver\PMC;..\..\Common\Plug\uartdevice;..\UI\MusicWin;..\..\Common\Plug\bsp;..\..\Common\Plug\shell;..\..\Common\Plug\uartdevice;..\..\Common\BBSystem;..\..\Common\Codec\Audio\AAC;..\..\Common\Codec\Audio\APE;..\..\Common\Codec\Audio\flac;..\..\Common\Codec\Audio\Ogg;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wma;..\..\Common\Codec\Audio\HIFI\ape;..\..\Common\Codec\Audio\HIFI\alac;..\..\Common\Codec\Audio\HIFI\flac;..\UI\TextWin;..\..\Common\Codec\Image\Thumbnail;..\..\Common\Driver\BB;..\UI\M3U;..\..\Common\Codec\BlueTooth;..\..\Common\Codec\BlueTooth\lwbt;..\..\Common\Codec\BlueTooth\lwbt\a2dp_source;..\..\Common\Codec\BlueTooth\lwbt\BLE;..\..\Common\Codec\BlueTooth\lwbt\chipset_cc2564;..\..\Common\Codec\BlueTooth\lwbt\chipset_rtk8761a;..\UI\BlueToothWin;..\UI\BlueToothWin\a2dpSoucreWin;..\..\Common\Codec\Audio\sbc;..\..\Common\Codec\Audio\SSRC;..\..\Common\Codec\Audio\sbc\sbc_encode;..\..\Common\Codec\Audio\SSRC\resampler
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
  link misc: --entry Main1 --keep ModuleInfo --keep exceptions_table --keep MainStack1 --keep V0_8K --keep V0_11K --keep V0_12K --keep V0_16K --keep V0_22K --keep V0_24K --keep V0_32K --keep V0_44K --keep V0_48K --keep V03_48K --keep V03_44K --keep V03_32K --keep V03_22K --keep V03_24K --keep V03_16K --keep V03_12K --keep V03_11K --keep V03_8K --keep V04_8K --keep V04_11K --keep V04_12K --keep V04_16K --keep V04_22K --keep V04_24K --keep V04_32K --keep V04_44K --keep V04_48K --keep V07_48K --keep V07_44K --keep V07_32K --keep V07_24K  --keep V07_22K --keep V07_16K --keep V07_12K --keep V07_11K --keep V07_8K --keep V09_8K --keep V09_11K --keep V09_12K --keep V09_16K --keep V09_22K --keep V09_24K --keep V09_32K --keep V09_44K --keep V09_48K --keep V10_48K --keep V10_44K --keep V10_32K --keep V10_24K --keep V10_22K --keep V10_16K --keep V10_12K --keep V10_11K --keep V10_8K --keep V11_8K --keep V11_11K --keep V11_12K --keep V11_16K --keep V11_22K --keep V11_24K --keep V11_32K --keep V11_44K --keep V11_48K --keep V08_48K --keep V08_44K --keep V08_32K  --keep V08_24K --keep V08_22K --keep V08_16K  --keep V08_12K --keep V08_11K --keep V08_8K --keep C3 --keep C5 --keep C9 --keep C21 --keep C22 --keep C49 --keep C50 --keep Eq_Table --keep mp3_code_bin --keep mp3_data_bin --keep mp3_enc_code_bin --keep mp3_enc_data_bin --keep wav_code_bin --keep wav_data_bin --keep aac_code_bin --keep aac_data_bin --keep wma_code_bin --keep wma_data_bin --keep flac_code_bin --keep flac_data_bin
  group Boot
    ../Scatter/: ScatterLoader.c
    ../../Common/BootLoader/: Start.s Cortex-m3.S
  group Driver
    ../../Common/Driver/PMU/: PMU.C
    ../../Common/Driver/ADC/: Adc.c
    ../../Common/Driver/DMA/: Dma.c
    ../../Common/Driver/I2C/: i2c.c
    ../../Common/Driver/IIS/: I2s.c
    ../../Common/Driver/GPIO/: gpio.c
    ../../Common/Driver/SPI/: Spi.c
    ../../Common/Driver/SYSTICK/: systick.c
    ../../Common/Driver/TIMER/: timer.c
    ../../Common/Driver/AD_KEY/: AD_Key.c
    ../../Common/Driver/UART/: uart.c
    ../../Common/Driver/DAC/rockcodec/: rockcodec.c
    ../../Common/Codec/UsbControl/: USBControl.c
    ../../Common/Driver/RadioDriver/QN8035/: hw_qn8035.c
    ../../Common/Driver/RadioDriver/FM5807/: hw_fm5807.c
    ../../Common/Driver/LCD/: Lcd_S6B0724_96x64.c ST7735Driver.c ST7735S_Driver_1.0.c
    ../../Common/Driver/DAC/wm8987/: hw_wm8987.c
    ../../Common/Driver/vop/: vop.c yuv2rgb.c
    ../../Common/Driver/mailbox/: mailbox.c
    ../../Common/Driver/CRU/: cru.c
    ../../Common/Driver/GRF/: grf.c
    ../../Common/Driver/PWM/: pwm.c
    ../../Common/Driver/WatchDog/: WatchDog.c
    ../../Common/Driver/DAC/ALC5633/: Hw_alc5633.c
    ../../Common/Driver/pmc/: pmc.c
    ../../Common/Driver/PVTM/: pvtm.c
    ../../Common/Driver/BB/: BBSystem.c
  group Plug
    ../../Common/Plug/bsp/: BSP.c
    ../../Common/Plug/uartdevice/: UartDevice.c
    ../../Common/Plug/shell/: ShellTask.c
  group System
    ../../Common/System/Debug/: Debug.c
    ../: main.c
    ../../Common/System/SysService/: Hook.c Delay.c Backlight.c battery.c Service.c UsbAdapterProbe.c voicedata0000.c voicedata0001.c voicedata0002.c voicedata0003.c voicedata0004.c voicedata0005.c voicedata0006.c voicedata0007.c voicedata0008.c PowerManager.c
    ../../Common/Display/: LcdCharLib.c LcdChar.c LcdImage.c LcdInterface.c 8859_x_12_add9.c 8859_x_12_Width_add9.c 8859_x_Table_add9.c COMP_NewJ_12_CJK.c COMP_NewJ_12_JKC.c COMP_NewJ_tbl.c FontLib.c getThaiChar.c THAI12.c
    ../../Common/System/Os/: interrupt.c SysTickHandler.c
    ../../Common/System/FileSeek/: SysFindFile.c
  group OsLib
    ../../Common/System/Os/: Msg.c Win.c Thread.c Task.c OsHook.c
    ../../Common/System/ModuleOverlay/: ModuleOverlay.c SysReservedOperation.c
    ../../Common/FwUpdate/: FwUpdate.c
  group FileSys
    ../../Common/FileSys/: Decode.c nFAT.c fat.c FDT.c dir.c file.c FileSeek.c
  group App
    ../UI/dialog/: DialogBox.c MessageBox.c LowPower.c Hold.c PowerOn_Off.c
    ../UI/MainMenu/: MainMenu.c MainMenuInterface.c
    ../UI/MusicWin/: MusicWin.c MusicWinInterface.c MusicLrc.c
    ../UI/RadioWin/: RadioWin.c RadioWinInterface.c
    ../UI/RadioWin/RadioSubWin/: RadioSubFreqWin.c RadioSubFuncWin.c RadioSubWinInterface.c
    ../UI/RecordWin/: RecordWin.c RecordWinInterface.c
    ../UI/Browser/BrowserUI/: BrowserUI.c
    ../UI/Browser/BroCore/: BroCore.c
    ../UI/SetMenu/: SetMenu.c SystemSet.c SetCommon.c SetMenuInterface.c SetMusic.c SetRadio.c SetRecord.c SetText.c SetBright.c BluetoothDevInfoWin.c BluetoothScanWin.c SetBluetooth.c BluetoothPinCodeWin.c
    ../UI/USB/: FunUSB.c FunUSBInterface.c
    ../UI/CharegeWin/: ChargeWin.c
    ../UI/PicWin/: PicInterface.c PicWin.c PicBroWin.c
    ../UI/TextWin/: TextBookmark.c TextInterface.c TextWin.c
    ../UI/M3U/: M3uBroWin.c M3uWin.c M3uWinSub.c
  group AudioControl
    ../../Common/Codec/Audio/AudioControl/: AudioControl.c HoldonPlay.c
    ../../Common/Codec/Audio/Common/: audio_file_access.c audio_track_control.c pCODECS.c
  group RecordControl
    ../../Common/Codec/Audio/RecordControl/: RecordControl.c
  group RadioControl
    ../../Common/Codec/Radio/FMControl/: FmControl.c
  group EqLib
    ../../Common/Codec/Audio/RkEQ/Effect/: Effect.c
    ../../Common/Codec/Audio/Library/: RkNano_Spectrum_V09_0420.lib
    ../../Common/Codec/Audio/RkEQ/: Fade.c filter_2_int_l.s filter_2_int_r.s rk_eq.c rk_eq_asm_opt.s
  group ShuffleLib
    ../../Common/Codec/Audio/ShuffleAll/myRandom/: myRandom.c
    ../../Common/Codec/Audio/ShuffleAll/: RKNANO_MyRandom_20160630.lib
  group Mp3Lib
    ../../Common/Codec/Audio/Mp3/: pMP3.c pMP32.c RkNanoD_MP3_SW_20180827.lib
  group Wmalib
    ../../Common/Codec/Audio/Wma/: pWMA.c pWMA2.c RkNanoD_WMA_20170328.lib
  group WavLib
    ../../Common/Codec/Audio/Wav/: pWAV.c pWAVEnc.c pWAV2.c RkNanoD_WAV_20151119.lib
  group AacLib
    ../../Common/Codec/Audio/AAC/: pAAC.c pAAC2.c RkNanoD_AAC_20190402.lib
  group FlacLib
    ../../Common/Codec/Audio/flac/: pFLAC.c pFLAC2.c RKNanoD_FLAC_20170602.lib
  group MP3EncLib
    ../../Common/Codec/Audio/MP3_ENC/: pMp3Enc.c RkNanoD_MP3Enc_20151119.lib
    ../../Common/Codec/Audio/MP3_ENC/MP3_enc_lib/: pMp3Enc2.c
  group NS
    ../../Common/Codec/Audio/RecordControl/: RkNanoD_NS_20151119.lib
  group ID3
    ../../Common/Codec/Audio/ID3/: ID3.c wma_parse.c AsicToUnicode.c AsicToUnicodeTable.c
  group media
    ../UI/medialib/: MediaBroWin.c medialibwin.c
    ../../Common/SortFileInfo/: FavoOperate.c FavoReset.c FileInfoSave.c SortInfoGet.c FileInfoSort.c
    ../UI/Medialib/: MDBBuildWin.c
  group USB
    ../../Common/Driver/USB/device/: storage.c USBDevice.c USBIsr.c USBSerial.c
    ../../Common/Driver/USB/: USBComm.c
  group MemDev
    ../../Common/Driver/MemDev/: MemDev.c
    ../../Common/Driver/MemDev/SD_MMC/: SDM.c eMMC.c MMC.c SD.c SDCtrl.c SDAdapt.c
    ../../Common/Driver/MemDev/SPIFlash/: SPIFlash.c SFC.c SFNand.c SFNor.c
  group ImageControl
    ../../Common/Codec/Image/ImageCommon/: image_common.c image_file_access.c pImageCODECS.c
    ../../Common/Codec/Image/Imagecontrol/: ImageControl.c
  group Thumbnail
    ../../Common/Codec/Image/Thumbnail/: thumbnail_parse.c Exif_Read.c Exif_Read_Main.c Thumbnail_Read_Main.c Thumbnail_Read_Task.c
  group JpgLib
    ../../Common/Codec/Image/Jpg/: pJPG.c jpgdec_init.c jpgdec_parser.c RkNanoD_JPG_DEC_V150906.lib
  group BmpLib
    ../../Common/Codec/Image/Bmp/: pBMPDEC.c RkNano_BMP_DEC_V20150511.lib
  group BTControl
    ../../Common/Codec/BlueTooth/: BlueToothA2dpSourceControl.c BlueToothSysParam.c
    ../../Common/Codec/BlueTooth/lwbt/: uartif.c btHwControl.c uartif_h5.c
    ../../Common/Codec/BlueTooth/lwbt/a2dp_source/: bt_ip_dt_source.c
    ../../Common/Codec/BlueTooth/lwbt/chipset_rtk8761a/: btRtk8761a_init_script.c btRtk8761aControl.c
  group LWBTLib
    ../../Common/Codec/BlueTooth/: RKNanoD_LwBT_20180716.lib
  group SBCEncodeLib
    ../../Common/Codec/Audio/sbc/sbc_encode/: sbc_enc_interface.c
    ../../Common/Codec/Audio/sbc/: RKNanoD_SBCEnc_20170613.lib
  group SSRCLib
    ../../Common/Codec/Audio/SSRC/: resample_interface.c RKNanoD_SSRC_20170214.lib
  group BBSystem
    ../../Common/BBSystem/: Start2.s Cortex-m32.S BSP2.c cru2.c Debug2.c Delay2.c dma2.c interrupt2.c systick2.c SysTickHandler2.c Main2.c pCODECS2.c audio_file_access2.c
  group BB_CORE_BIN
    ../../Common/System/SysService/: bb_core.c
target MP3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o MP3\RkNano.bin  MP3\RkNano.axf
  AfterMake: mp3.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: MP3_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
target WMA (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o WMA\RkNano.bin  WMA\RkNano.axf
  AfterMake: wma.bat
  c flags: Optim=3 oTime=1 wLevel=1
  c define: WMA_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
target WAV (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o WAV\RkNano.bin  WAV\RkNano.axf
  AfterMake: wav.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: WAV_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
target AAC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o AAC\RkNano.bin  AAC\RkNano.axf
  AfterMake: aac.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: AAC_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
target FLAC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o FLAC\RkNano.bin  FLAC\RkNano.axf
  AfterMake: flac.bat
  c flags: Optim=3 wLevel=1
  c define: FLAC_DEC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
target MP3Enc (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o MP3ENC\RkNano.bin  MP3ENC\RkNano.axf
  AfterMake: mp3enc.bat
  c flags: Optim=4 oTime=1 wLevel=1
  c define: MP3_ENC_INCLUDE2, B_CORE_DECODE
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\B_Core.sct
target Shuffle_Lib (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RKNANO_MyRandom (library)
  c flags: Optim=3 oTime=1 wLevel=1
  c include: as above
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
